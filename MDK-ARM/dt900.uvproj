# Keil uVision project dt900.uvproj, settings and files
target dt900 Configuration (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: dt900 Configuration +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FatFs\src;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\BSP;..\Middlewares\ST\STemWin\inc;..\Middlewares\ST\STemWin\Config;..\Src\UI;..\Middlewares\STM32_USB_Device_Library\Class\msc\inc;..\Middlewares\STM32_USB_Device_Library\Core\inc;..\Middlewares\STM32_USB_OTG_Driver\inc;..\Src\usbd_mass_storage
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c event_groups.c croutine.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STemWin
    ../Middlewares/ST/STemWin/Config/: GUIConf.c LCDConf_Lin_Template.c
    ../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
    ../Middlewares/ST/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
    ../Middlewares/ST/: Helvetica32.c HelveticaNeueLT48.c
  group Drivers/BSP
    ../Drivers/BSP/: pwr.c spiflash.c adc.c beep.c sdram.c lcd.c init.c dac8831.c ad7190.c flash.c rtc.c cyma568.c ds18b20.c
  group Application/User
    ../Src/: fatfs.c freertos.c stm32f4xx_hal_msp.c user_diskio.c stm32f4xx_it.c main.c geotest.c fft.c ostask.c
    ../Src/usbd_mass_storage/: usb_bsp.c usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group UI
    ../Src/UI/: ui.c pMain.c pSettings.c pSubSettings.c pKeyboard.c pEditD.c pEditF.c pEditR.c pEditS.c pGeoParam.c pTest.c pSetup.c pSys.c pTime.c pString.c pFlow.c pAbout.c pZVF.c
  group Middlewares/USB_Device_Library
    ../Middlewares/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Middlewares/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
